# Keil uVision project M051_ldrom.uvprojx, settings and files
target M051_ldrom (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M0516ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: M051_ldrom +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  .\OBJ\M051_ldrom.bin  .\OBJ\M051_ldrom.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\inc;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group src
    ../src/: main.c sysinit.c
  group inc
    ../inc/: Interrupt.h
  group Neuron
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group Library
    ../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c gpio.c
  group doc
    ../doc/: readme.txt
target M051_bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M0516ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: as above
  output: M051_bootloader +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  .\OBJ\M051_bootloader.bin  .\OBJ\M051_bootloader.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler

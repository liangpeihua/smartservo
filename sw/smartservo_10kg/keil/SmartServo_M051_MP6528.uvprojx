# Keil uVision project SmartServo_M051_MP6528.uvprojx, settings and files
target M051_ZW_Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M0516ZAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SmartServo_M051_MP6528 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  .\Objects\SmartServo_M051_MP6528.bin  .\Objects\SmartServo_M051_MP6528.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\inc;..\src\servo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group Neuron
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group src
    ./: startup_M051Series.s
    ../src/: uart_printf.c main.c systime.c mygpio.c MePwm.c protocol.c Interrupt.c sysinit.c dataflash.c mp9960.c rgb.c
  group src/servo
    ../src/servo/: servo_control.c servo_detect.c servo_driver.c usart_fun.C
  group inc
    ../inc/: uart_printf.h systime.h mygpio.h protocol.h Interrupt.h sysinit.h dataflash.h smartservo.h mp9960.h main.h rgb.h
    ../src/servo/: servo_control.h servo_detect.h servo_driver.h
  group Library
    ../inc/: MePwm.h
    ../Library/StdDriver/src/: retarget.c sys.c uart.c i2c.c timer.c clk.c gpio.c fmc.c pwm.c spi.c
  group doc
    ../doc/: readme.txt
target M051_ZW_Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: M058ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SmartServo_FW +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  .\Objects\SmartServo_FW.bin  .\Objects\SmartServo_FW.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
